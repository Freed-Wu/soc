## assets/configs/rootfsconfigs/Kconfig.user
```kconfig
# project-spec/configs/rootfsconfigs/Kconfig.user
config autostart-dbg
	 bool "autostart-dbg"
	 help
```
